require recipes-mitysom/images/mitysom-335x-devkit.bb

PREFERRED_PROVIDER_virtual/kernel ?= "linux-mitysom335x-tiwi"
