FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0017-qt5-workaround-gcc48-arm-build-failure.patch"
