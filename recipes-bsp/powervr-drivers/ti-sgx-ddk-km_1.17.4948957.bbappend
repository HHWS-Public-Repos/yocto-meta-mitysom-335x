EXTRA_OEMAKE = 'KERNELDIR="${STAGING_KERNEL_BUILDDIR}" TARGET_PRODUCT=${TARGET_PRODUCT} WINDOW_SYSTEM=nulldrmws TARGET_PRIMARY_ARCH=target_armhf'
